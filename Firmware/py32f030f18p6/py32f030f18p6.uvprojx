# Keil uVision project py32f030f18p6.uvprojx, settings and files
target Target (6220000::V6.22::ARMCLANG)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: py32f030f18p6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32F030x8 USE_FULL_LL_DRIVER
  c include: .\;.\Libraries\PY32F0xx_LL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: main.c py32f0xx_it.c
    ./Libraries/PY32F0xx_LL_Driver/Src/: py32f0xx_ll_utils.c py32f0xx_ll_flash.c py32f0xx_ll_usart.c py32f0xx_ll_gpio.c py32f0xx_ll_rcc.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
